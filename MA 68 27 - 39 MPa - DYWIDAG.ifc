Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: dedeae04-81ed-45a2-8f00-4d54dae0b279, NumberOfSaves: 1], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
Time: 2023-11-15T12:34:08+01:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.10.25 (DEU) - IFC 24.1.10.25

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene 1, Ebene 1
LongName: Ebene 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Ebene 1; sets with these values: 2

# IfcBuildingElementProxy: 94 00 1017 - ISO kopie:94 00 1017 - ISO kopie, 94 00 1017 - ISO kopie:94 00 1017 - ISO kopie:1:2719
In: Ebene 1
Pset_BuildingElementProxyCommon - Reference: 94 00 1017 - ISO kopie; sets with these values: 2
